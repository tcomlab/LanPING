<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ESL_LanPING_Device.ewp</path>
  </project>
  <batchBuild/>
</workspace>


