# IAR project ESL_LanPING_Device.ewp, settings and files
configuration base_config_debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM7S32 Atmel AT91SAM7S32
  ICCARM.CCDefines: PROTO_BORD
  ICCARM.CCIncludePath2: startups\; startups\at91sam7s32\; Sources\; Sources\uip\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam7s32; flash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: ESL_LanPING_Device.srec
  ILINK.IlinkOutputFile: ESL_LanPING_Device.out
  ILINK.IlinkIcfFile: startups\at91SAM7S32_FLASH.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
  group Source/App
    Sources/: at91flash.c CP2200.c main.c memb.c shell.c telnetd.c
  group Source/uIP
    Sources/uip/: timer.c uip.c uip_arp.c
  group StartUp
    startups/: board_cstartup_iar.s board_lowlevel.c
